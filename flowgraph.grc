options:
  parameters:
    author: guill
    generate_options: no_gui
    id: NRP
    output_language: python
    title: Numerical Research Project
  states: {}

blocks:
- name: audio_hi
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: audio_lo
  id: variable
  parameters:
    value: '100'
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: 81.3e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: samp_rate1
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: sq_thresh
  id: variable
  parameters:
    value: '-60'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.001'
    gate: 'False'
    ramp: '0'
    threshold: sq_thresh
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '192000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: audio_hi
    low_cutoff_freq: audio_lo
    samp_rate: '48000'
    type: fir_filter_fff
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 100e3, 20e3)
    type: ccc
  states: {}
- name: nrp_signal_analyzer_0
  id: nrp_signal_analyzer
  parameters:
    alpha: '0.001'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    bufflen: '262144'
    center_freq: cent_freq
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8080'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
    type: float
    vlen: '2'
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', band_pass_filter_0, '0']
- [analog_wfm_rcv_0, '0', nrp_signal_analyzer_0, '0']
- [analog_wfm_rcv_0, '0', zeromq_pub_sink_0, '0']
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [blocks_streams_to_vector_0, '0', zeromq_pub_sink_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [nrp_signal_analyzer_0, '0', blocks_streams_to_vector_0, '0']
- [nrp_signal_analyzer_0, '1', blocks_streams_to_vector_0, '1']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
